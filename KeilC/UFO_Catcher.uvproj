# Keil uVision project UFO_Catcher.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UFO_Catcher +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\include\delay;.\include\play_mode;.\include\uart_init
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c
    ./include/uart_init/: uart_init.c
    ./include/play_mode/: play_mode.c
    ./include/delay/: delay.c
